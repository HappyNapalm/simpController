# Repository HappyNapalm/simpController

File README.md:

# simpController
A repo containing a simple controller project. 

# Concept
This will be an easy to follow educational guide on how to build a controller.

## KiCad design KiCAD/comparator/comparator.kicad_pcb

File KiCAD/README.md:

# TODO LIST #
* Test the boards *

## Feedback on Build ##
* Discovered weird voltage drops on the silicone buttons. 
* The chassis hole from the joysticks are the wrong size.
* Dimensions are too off from printing on Taz Mini.

Parts:
C1, C2: 0.1uF; C_0603_1608Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Output; TerminalBlock_RND_205-00240_1x10_P5.08mm_Horizontal
J2: Input; TerminalBlock_RND_205-00240_1x10_P5.08mm_Horizontal
RN1, RN2: 1.1k; R_Array_Convex_4x0603
RV1: R_POT_US; P120PK-Y25BR10K
U1, U2: TLC3704; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
1: J1.10, U1.2
2: J1.9, U1.1
3: J1.8, U1.13
4: J1.7, U1.14
5: J1.6, U2.2
6: J1.5, U2.1
7: J1.4, U2.13
8: J1.3, U2.14
+5V: C1.1, C2.1, J1.2, J2.2, RV1.1, U1.3 (V+), U2.3 (V+)
A: J2.10, RN1.1 (R1.1), U1.5 (+)
B: J2.9, RN1.2 (R2.1), U1.7 (+)
C: J2.8, RN1.3 (R3.1), U1.11 (+)
D: J2.7, RN1.4 (R4.1), U1.9 (+)
E: J2.6, RN2.1 (R1.1), U2.5 (+)
F: J2.5, RN2.2 (R2.1), U2.7 (+)
G: J2.4, RN2.3 (R3.1), U2.11 (+)
GNDREF: C1.2, C2.2, J1.1, J2.1, RN1.5 (R4.2), RN1.6 (R3.2), RN1.7 (R2.2), RN1.8 (R1.2), RN2.5 (R4.2), RN2.6 (R3.2), RN2.7 (R2.2), RN2.8 (R1.2), RV1.3, U1.12 (V-), U2.12 (V-)
H: J2.3, RN2.4 (R4.1), U2.9 (+)
Trimmer: RV1.2, U1.4 (-), U1.6 (-), U1.8 (-), U1.10 (-), U2.4 (-), U2.6 (-), U2.8 (-), U2.10 (-)

Board: 2 copper layers, 71.6 x 34.5 mm, 13 parts (0 on the bottom side), 19 nets.

## KiCad design KiCAD/Arduino_control_board/Arduino_control_board.kicad_pcb

Parts:
A1: Arduino_Nano_v3.x; Arduino_Nano
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Buttons 0; TerminalBlock_RND_205-00297_1x12_P5.08mm_Horizontal
J2: Buttons 1; TerminalBlock_RND_205-00297_1x12_P5.08mm_Horizontal
J3: Screw_Terminal_01x10; TerminalBlock_RND_205-00240_1x10_P5.08mm_Horizontal
RN1, RN2, RN3, RN4, RN5, RN6, RN7, RN8, RN9, RN10, RN11, RN12, RN13, RN14: R_Pack04; R_Array_Convex_4x0603
SW1, SW2: SW_DPDT_x2; JS202011SCQN

Connections:
A: A1.19 (A0), J3.5
B: A1.20 (A1), J3.6
B1: J1.1, RN1.1 (R1.1)
B1_O: A1.21 (A2), RN1.2 (R2.1), RN5.5 (R4.2)
B2: J1.2, RN1.3 (R3.1)
B2_O: RN1.4 (R4.1), RN5.3 (R3.1), RN5.4 (R4.1)
B3: J1.3, RN2.1 (R1.1)
B3_O: RN2.2 (R2.1), RN5.6 (R3.2), RN5.7 (R2.2)
B4: J1.4, RN2.3 (R3.1)
B4_O: RN2.4 (R4.1), RN5.1 (R1.1), RN5.2 (R2.1)
B5: J1.5, RN3.1 (R1.1)
B5_O: RN3.2 (R2.1), RN5.8 (R1.2), RN6.1 (R1.1)
B6: J1.6, RN3.3 (R3.1)
B6_O: RN3.4 (R4.1), RN6.7 (R2.2), RN6.8 (R1.2)
B7: J1.7, RN4.1 (R1.1)
B7_O: RN4.2 (R2.1), RN6.2 (R2.1), RN6.3 (R3.1)
B8: J1.8, RN4.3 (R3.1)
B8_O: RN4.4 (R4.1), RN6.5 (R4.2), RN6.6 (R3.2)
B09: J2.1, RN8.1 (R1.1)
B09_O: A1.22 (A3), RN8.2 (R2.1), RN12.5 (R4.2)
B10: J2.2, RN8.3 (R3.1)
B10_O: RN8.4 (R4.1), RN12.3 (R3.1), RN12.4 (R4.1)
B11: J2.3, RN9.1 (R1.1)
B11_O: RN9.2 (R2.1), RN12.6 (R3.2), RN12.7 (R2.2)
B12: J2.4, RN9.3 (R3.1)
B12_O: RN9.4 (R4.1), RN12.1 (R1.1), RN12.2 (R2.1)
B13: J2.5, RN10.1 (R1.1)
B13_O: RN10.2 (R2.1), RN12.8 (R1.2), RN13.1 (R1.1)
B14: J2.6, RN10.3 (R3.1)
B14_O: RN10.4 (R4.1), RN13.7 (R2.2), RN13.8 (R1.2)
B15: J2.7, RN11.1 (R1.1)
B15_O: RN11.2 (R2.1), RN13.2 (R2.1), RN13.3 (R3.1)
B16: J2.8, RN11.3 (R3.1)
B16_O: RN11.4 (R4.1), RN13.5 (R4.2), RN13.6 (R3.2)
D_OUT_0: A1.11 (D8), J1.11
D_OUT_1: A1.12 (D9), J2.11
GND: A1.4 (GND), A1.29 (GND), J1.10, J2.10, J3.8, J3.9, J3.10, RN7.8 (R1.2), RN14.8 (R1.2), SW1.3 (C), SW2.6 (C)
unnamed: RN1.5 (R4.2), RN1.6 (R3.2)
unnamed: RN1.7 (R2.2), RN1.8 (R1.2)
unnamed: RN2.5 (R4.2), RN2.6 (R3.2)
unnamed: RN2.7 (R2.2), RN2.8 (R1.2)
unnamed: RN3.5 (R4.2), RN3.6 (R3.2)
unnamed: RN3.7 (R2.2), RN3.8 (R1.2)
unnamed: RN4.5 (R4.2), RN4.6 (R3.2)
unnamed: RN4.7 (R2.2), RN4.8 (R1.2)
unnamed: RN6.4 (R4.1), RN7.1 (R1.1)
unnamed: RN8.5 (R4.2), RN8.6 (R3.2)
unnamed: RN8.7 (R2.2), RN8.8 (R1.2)
unnamed: RN9.5 (R4.2), RN9.6 (R3.2)
unnamed: RN9.7 (R2.2), RN9.8 (R1.2)
unnamed: RN10.5 (R4.2), RN10.6 (R3.2)
unnamed: RN10.7 (R2.2), RN10.8 (R1.2)
unnamed: RN11.5 (R4.2), RN11.6 (R3.2)
unnamed: RN11.7 (R2.2), RN11.8 (R1.2)
unnamed: RN13.4 (R4.1), RN14.1 (R1.1)
S1: A1.5 (D2), J3.4
S2: A1.6 (D3), J3.7
SW0: A1.14 (D11), RN7.6 (R3.2), SW1.2 (B)
SW1: A1.15 (D12), RN7.5 (R4.2), SW2.5 (B)
VCC: A1.27 (+5V), J1.9, J2.9, J3.1, J3.2, J3.3, RN7.3 (R3.1), RN7.4 (R4.1), SW1.1 (A), SW2.4 (A)

Board: 2 copper layers, 87.2 x 83.9 mm, 25 parts (0 on the bottom side), 60 nets.

Other parts of the board:
0: THK_002_Labels

## KiCad design KiCAD/Buttons/Sparkfun_buttons/Sparkfun_buttons.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1, D2, D3, D4, D5, D6, D7, D8: LTST-E563CEGBW; LTST-E563CEGBW_RGB_LED_4pad_5x4
H1, H2, H3: MountingHole; MountingHole_3.2mm_M3
J1: Screw_Terminal_01x12; TerminalBlock_RND_205-00022_1x12_P5.00mm_Horizontal
RN1, RN2, RN3, RN4: R_Pack04; R_Array_Convex_4x0603
SW1: 15mm_Silicone_Buttons; SF_ COM_07835

Connections:
B1: J1.1, RN1.5 (R4.2), SW1.2
B2: J1.2, RN1.6 (R3.2), SW1.4
B3: J1.3, RN1.7 (R2.2), SW1.6
B4: J1.4, RN1.8 (R1.2), SW1.8
B5: J1.5, RN2.5 (R4.2), SW1.10
B6: J1.6, RN2.6 (R3.2), SW1.12
B7: J1.7, RN2.7 (R2.2), SW1.14
B8: J1.8, RN2.8 (R1.2), SW1.16
Dcon: D4.3 (DO), D5.2 (DIN)
Din: D1.2 (DIN), J1.11
Dout: D8.3 (DO), J1.12
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, D1.1 (Vss), D2.1 (Vss), D3.1 (Vss), D4.1 (Vss), D5.1 (Vss), D6.1 (Vss), D7.1 (Vss), D8.1 (Vss), J1.10, RN1.1 (R1.1), RN1.2 (R2.1), RN1.3 (R3.1), RN1.4 (R4.1), RN2.1 (R1.1), RN2.2 (R2.1), RN2.3 (R3.1), RN2.4 (R4.1)
unnamed: C1.1, D1.4 (Vdd), RN3.5 (R4.2)
unnamed: C2.1, D5.4 (Vdd), RN4.5 (R4.2)
unnamed: C3.1, D2.4 (Vdd), RN3.6 (R3.2)
unnamed: C4.1, D6.4 (Vdd), RN4.6 (R3.2)
unnamed: C5.1, D3.4 (Vdd), RN3.7 (R2.2)
unnamed: C6.1, D7.4 (Vdd), RN4.7 (R2.2)
unnamed: C7.1, D4.4 (Vdd), RN3.8 (R1.2)
unnamed: C8.1, D8.4 (Vdd), RN4.8 (R1.2)
unnamed: D1.3 (DO), D2.2 (DIN)
unnamed: D2.3 (DO), D3.2 (DIN)
unnamed: D3.3 (DO), D4.2 (DIN)
unnamed: D5.3 (DO), D6.2 (DIN)
unnamed: D6.3 (DO), D7.2 (DIN)
unnamed: D7.3 (DO), D8.2 (DIN)
Vcc: J1.9, RN3.1 (R1.1), RN3.2 (R2.1), RN3.3 (R3.1), RN3.4 (R4.1), RN4.1 (R1.1), RN4.2 (R2.1), RN4.3 (R3.1), RN4.4 (R4.1), SW1.1, SW1.3, SW1.5, SW1.7, SW1.9, SW1.11, SW1.13, SW1.15

Board: 2 copper layers, 100.0 x 70.0 mm, 25 parts (12 on the bottom side), 27 nets.

## KiCad design KiCAD/joystick/joystick.kicad_pcb

Board: 2 copper layers, 42.2 x 48.4 mm, 7 parts (0 on the bottom side), 5 nets.

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: Screw_Terminal_01x05; TerminalBlock_RND_205-00235_1x05_P5.08mm_Horizontal
JS1: thb-1841844; C&K_THB001P
R1: R_US; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder

Connections:
Aout: J1.3, JS1.2
Bout: J1.4, JS1.5
GND: J1.2, JS1.3, JS1.6, R1.2
Sout: J1.5, JS1.7, R1.1
Vcc: J1.1, JS1.1, JS1.4, JS1.8

## KiCad design KiCAD/ScratchPad/scratch_Arduino/scratch.kicad_pcb

Board: 2 copper layers, 100.0 x 50.0 mm, 7 parts (0 on the bottom side), 7 nets, no tracks yet.

Parts:
A1: Arduino_Nano_v2.x; Arduino_Nano
R1, R2, R3, R4, R5, R6: 220; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder

Connections:
+5V: A1.27, R3.2
B1: A1.13, R1.1
B2: A1.12, R2.1
B3: A1.11, R5.1
B4: A1.10, R6.1
GNDREF: A1.4, A1.29, R1.2, R2.2, R4.2, R5.2, R6.2
JB1: A1.6, R4.1

## Commit log

2020-05-10 Working on the structure for the Arduino sub dir. Added KiCAD sketch pad and read me.
2020-05-10 Added RC debounce simulation and Arduino table
2020-05-10 table editting
2020-05-10 Worked on basic schematic
2020-05-10 book keeping
2020-05-10 add some more structure
2020-05-10 pushing new readme to determine formating on github's side
2020-05-13 Lesson structure
2020-05-13 adding reference photo
2020-05-13 Added a scratch pad for arduino software. Addressed a potential problem in schematic.
2020-05-26 TODO button and joystick footprint design
2020-05-30 Arduino nano does not support Keyboard.h from Arduino HAL.
2020-05-31 working on secondary processor
2020-06-02 making a work in progress branch distinct from the main branch.
2020-06-02 Working on markdown.
2020-06-03 made a shell with the arduino code.
2020-06-11 Added docs and bulk open software from NXP.
2020-06-11 Flashed blinky
2020-06-13 saving progress on spark fun silicone button interface
2020-06-14 Finished a basic footprint layout.
2020-06-14 TODO add deadzone to joystick code
2020-06-16 Dead zone is +/- 30 counts from the ADC. Maybe switch to periodic recentering?
2020-06-16 did some schematic work on the buttons. Still lots todo. Added todo to nxp/kicad/readme
2020-06-16 moving Arduino code from wip into main branch
2020-06-16 Found the schematic for the MANLEY dev kit. That unit was put EOL from NXP. Might need to reconsider the expected life of this chip...
2020-06-17 working on keyboard. Made symbol for stock 596 shift register.
2020-06-17 made symbol from data controlled LEDs from liteon. Will cut down on hardware costs.
2020-06-25 WIP button board with initial layout ready for review.
2020-06-26 added a joystick schematic. TODO make a footprint. The C&K drawing is strange.
2020-06-28 Finished joystick design and layout.
2020-06-28 made a controller schematic for the Arduino nano. this project needs a restructing.
2020-06-30 add mode switches to schematic
2020-07-02 finsihed basic idea of arduino board. TODO: layout
2020-07-02 80% done with the controller. Will have done and ready for review this friday.
2020-07-11 Redid renders to match silkscreen and soldermask for the button board. Generated step files to assist in 3d modeling.
2020-07-14 Updated todo list on /KiCAD/ to represent the testing that is being done on the boards.
2020-07-19 saving work. Need to clean up project. FAB problems being addressed.
2020-07-29 finished some layout on the comparator for the buttons. need to finish silkscreen before gerber generation.
2020-08-02 saving comparator progress
2020-10-03 verified that the adafruit library works on adafruit brand A-LEDs. Moving on to testing Liteon brand.
2020-10-03 Adding FOSS Arduino Lib made by Adafruit to local dir. All rights and credits are to Adafruit. Thank you for making this software free to use.
2021-02-10 Added a tweaker pot for sensitivity testing
2021-02-11 added trimmer pot to the layout
